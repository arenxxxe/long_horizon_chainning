Commit message: 吓死了 重新下载回最新代码 但是setup py变了

File: chaining_package/ENV/3d_asset/3d_model/kuka_grasp/block.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link block_2_base_link: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
